# Keil uVision project uCOS-III.uvprojx, settings and files
target FLASH (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uCOS-III
  c flags: v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\..\BSP;..\..\BSP\OS;..\..\BSP\ST\inc;..\..\uC-CPU;..\..\uC-LIB;..\..\uC-Serial;..\..\uCOS-III-Ports;..\..\uCOS-III-Source;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\..\BSP\ST;..\..\F4Boards;..\KeilMDK;..\..\APP;..\HARDWARE\MPU6050;..\HARDWARE\PWM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c
    ../../BSP/StartUp/: cstartup.s
    ../../BSP/OS/: bsp_os.c bsp_os.h
  group uC/CPU
    ../../uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group uC/OS-III Source
    ../../uCOS-III-Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/OS-III Port
    ../../uCOS-III-Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/Serial
    ../../uC-Serial/: serial.c serial.h serial_bsp_stm3240x.c serial_bsp_stm3240x.h serial_buf.c serial_buf.h serial_drv_stm32.c serial_drv_stm32.h serial_line_dflt.c serial_line_dflt.h serial_line_probe.c serial_line_probe.h serial_line_tty.c serial_line_tty.h serial_os.h serial_type.h serial_os.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/PWM/: pwm.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c usart.h
    ../SYSTEM/sys/: sys.c sys.h
  group STM32F4xx Library
    ../../BSP/ST/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group APP
    ../../APP/: app.c app_cfg.h app_serial.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h stm32f4xx.h stm32f4xx_conf.h app_serial.c main.c
software components: CMSIS:CORE 4.3.0
